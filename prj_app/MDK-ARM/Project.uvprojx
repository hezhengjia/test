# Keil uVision project Project.uvprojx, settings and files
target STM324xG_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: u1_gateway_firmware +hex
  AfterMake: fromelf --bin ".\bin\@L.axf" --output "..\..\output\@L.app"
  AfterMake: ..\..\Tools\merger_bin.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40XX,USE_STM324x7I_EVAL,USE_DHCP
  c include: ..\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4x7_ETH_Driver\inc;..\Utilities\STM32_EVAL\Common;..\Utilities\STM32_EVAL\STM3240_41_G_EVAL;..\Utilities\Third_Party\lwip-1.4.1\src\include;..\Utilities\Third_Party\lwip-1.4.1\src\include\lwip;..\Utilities\Third_Party\lwip-1.4.1\src\include\netif;..\Utilities\Third_Party\lwip-1.4.1\src\include\ipv4;..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4x7;..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4x7\FreeRTOS;..\Utilities\Third_Party\FreeRTOSV7.3.0\portable\RVDS\ARM_CM4F;..\Utilities\Third_Party\FreeRTOSV7.3.0\include;..\Utilities\STM32_EVAL\STM324x7I_EVAL;..\BSP\SRAM;..\BSP;..\PolarSSL\polarssl-2.6.0-Apache\include;..\PolarSSL\polarssl-2.6.0-Apache\include\mbedtls;..\MQTT;..\BSP\UART;..\src2;..\src;..\cfg;..\system;..\application;..\driver
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cfg
    ../cfg/: all_cfg.h version.h io_config.h
  group User
    ../Utilities/STM32_EVAL/STM324x7I_EVAL/: app.c
    ../src2/: protocol_uart.c bytes_fifo_malloc.c
    ../src/: main.c stm32f4xx_it.c mqttclient.c netconf.c stm32f4x7_eth_bsp.c fs.c httpserver-socket.c in_flash_manage.c system_stm32f4xx.c
    ./: startup_stm32f4xx.s
  group BSP
    ../src2/: stmflash.c byte_fifo.c cJSON.c iwdg.c rng.c malloc.c rtc.c rtc.h
    ../BSP/UART/: uart.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_usart.c misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_i2c.c stm32f4xx_rng.c stm32f4xx_iwdg.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group STM32F4x7_ETH_Driver
    ../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group LwIP
    ../Utilities/Third_Party/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Utilities/Third_Party/lwip-1.4.1/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c timers.c def.c
    ../Utilities/Third_Party/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../Utilities/Third_Party/lwip-1.4.1/src/netif/: etharp.c
    ../Utilities/Third_Party/lwip-1.4.1/port/STM32F4x7/FreeRTOS/: ethernetif.c sys_arch.c
  group FreeRTOS
    ../Utilities/Third_Party/FreeRTOSV7.3.0/portable/MemMang/: heap_4.c
    ../Utilities/Third_Party/FreeRTOSV7.3.0/: tasks.c croutine.c list.c queue.c
    ../Utilities/Third_Party/FreeRTOSV7.3.0/portable/RVDS/ARM_CM3/: port.c
    ../Utilities/Third_Party/FreeRTOSV7.3.0/CMSIS_RTOS/: cmsis_os.c
  group PolarSSL
    ../PolarSSL/polarssl-2.6.0-Apache/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group MQTT
    ../MQTT/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c transport.c
  group rtt
    ../src2/: SEGGER_RTT_Printf.c SEGGER_RTT.c rtt_printf.h
  group system
    ../system/: my_sys.h
    ../system/assert/: sys_assert.c
    ../system/console/: console.c
    ../system/id_handle_map/: id_handle_map.c
    ../system/xmodem/: xmodem.c
  group driver
    ../driver/: driver_com.h
    ../driver/drv_key/: drv_out_key_cfg.h drv_key_gesture.c drv_key.c
  group application
    ../application/: application.h
    ../application/command/: app_command.c
target STM324x7I_EVAL (ARM-ADS)
  device: STM32F437II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM324xG_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427X,USE_STM324x7I_EVAL
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\Utilities\STM32_EVAL\STM324x7I_EVAL;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\lwip;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\netif;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\src\include\ipv4;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4x7;..\..\..\..\Utilities\Third_Party\lwip-1.4.1\port\STM32F4x7\FreeRTOS;..\..\..\..\Utilities\Third_Party\FreeRTOSV7.3.0\portable\RVDS\ARM_CM3;..\..\..\..\Utilities\Third_Party\FreeRTOSV7.3.0\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 4.3.0, Data Exchange:JSON:Jansson 2.7.0
